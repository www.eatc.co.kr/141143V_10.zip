# Autodesk Inventor part: 플레이트
## iProperties
Created: 2014-06
Part Number: 플레이트
Document SubType Name: Modeling
Designer: SeoGD™[esajin.kr]
Density: 1 g/cm^3
Author: SeoGD™[esajin.kr]
